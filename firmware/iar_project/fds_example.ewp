# IAR project fds_example.ewp, settings and files
configuration nrf52832_xxaa (ARM)
  General.OGChipSelectEditMenu: nrf52832_xxaa nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BOARD_PCA10040; CONFIG_GPIO_AS_PINRESET; DEVELOP_IN_NRF52832; FLOAT_ABI_SOFT; NRF52832_XXAA; NRF52_PAN_74; SWI_DISABLE0; CONFIG_NFCT_PINS_AS_GPIOS; DEBUG
  ICCARM.CCIncludePath2: ..\components; ..\components\ble\ble_advertising; ..\components\ble\ble_dtm; ..\components\ble\ble_racp; ..\components\ble\ble_services\ble_ancs_c; ..\components\ble\ble_services\ble_ans_c; ..\components\ble\ble_services\ble_bas; ..\components\ble\ble_services\ble_bas_c; ..\components\ble\ble_services\ble_cscs; ..\components\ble\ble_services\ble_cts_c; ..\components\ble\ble_services\ble_dfu; ..\components\ble\ble_services\ble_dis; ..\components\ble\ble_services\ble_gls; ..\components\ble\ble_services\ble_hids; ..\components\ble\ble_services\ble_hrs; ..\components\ble\ble_services\ble_hrs_c; ..\components\ble\ble_services\ble_hts; ..\components\ble\ble_services\ble_ias; ..\components\ble\ble_services\ble_ias_c; ..\components\ble\ble_services\ble_lbs; ..\components\ble\ble_services\ble_lbs_c; ..\components\ble\ble_services\ble_lls; ..\components\ble\ble_services\ble_nus; ..\components\ble\ble_services\ble_nus_c; ..\components\ble\ble_services\ble_rscs; ..\components\ble\ble_services\ble_rscs_c; ..\components\ble\ble_services\ble_tps; ..\components\ble\common; ..\components\ble\nrf_ble_gatt; ..\components\ble\nrf_ble_qwr; ..\components\ble\peer_manager; ..\components\boards; ..\components\drivers_nrf\usbd; ..\components\libraries\atomic; ..\components\libraries\atomic_fifo; ..\components\libraries\atomic_flags; ..\components\libraries\balloc; ..\components\libraries\bootloader\ble_dfu; ..\components\libraries\bsp; ..\components\libraries\button; ..\components\libraries\cli; ..\components\libraries\crc16; ..\components\libraries\crc32; ..\components\libraries\crypto; ..\components\libraries\csense; ..\components\libraries\csense_drv; ..\components\libraries\delay; ..\components\libraries\ecc; ..\components\libraries\experimental_log; ..\components\libraries\experimental_log\src; ..\components\libraries\experimental_memobj; ..\components\libraries\experimental_mpu; ..\components\libraries\experimental_ringbuf; ..\components\libraries\experimental_section_vars; ..\components\libraries\experimental_stack_guard; ..\components\libraries\experimental_task_manager; ..\components\libraries\fds; ..\components\libraries\fstorage; ..\components\libraries\gfx; ..\components\libraries\gpiote; ..\components\libraries\hardfault; ..\components\libraries\hci; ..\components\libraries\led_softblink; ..\components\libraries\low_power_pwm; ..\components\libraries\mem_manager; ..\components\libraries\mutex; ..\components\libraries\pwm; ..\components\libraries\pwr_mgmt; ..\components\libraries\queue; ..\components\libraries\scheduler; ..\components\libraries\sdcard; ..\components\libraries\sensorsim; ..\components\libraries\slip; ..\components\libraries\sortlist; ..\components\libraries\spi_mngr; ..\components\libraries\strerror; ..\components\libraries\timer; ..\components\libraries\twi_mngr; ..\components\libraries\twi_sensor; ..\components\libraries\usbd; ..\components\libraries\usbd\class\audio; ..\components\libraries\usbd\class\cdc; ..\components\libraries\usbd\class\cdc\acm; ..\components\libraries\usbd\class\hid; ..\components\libraries\usbd\class\hid\generic; ..\components\libraries\usbd\class\hid\kbd; ..\components\libraries\usbd\class\hid\mouse; ..\components\libraries\usbd\class\msc; ..\components\libraries\usbd\config; ..\components\libraries\util; ..\components\nfc\ndef\conn_hand_parser; ..\components\nfc\ndef\conn_hand_parser\ac_rec_parser; ..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser; ..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser; ..\components\nfc\ndef\connection_handover\ac_rec; ..\components\nfc\ndef\connection_handover\ble_oob_advdata; ..\components\nfc\ndef\connection_handover\ble_pair_lib; ..\components\nfc\ndef\connection_handover\ble_pair_msg; ..\components\nfc\ndef\connection_handover\common; ..\components\nfc\ndef\connection_handover\ep_oob_rec; ..\components\nfc\ndef\connection_handover\hs_rec; ..\components\nfc\ndef\connection_handover\le_oob_rec; ..\components\nfc\ndef\generic\message; ..\components\nfc\ndef\generic\record; ..\components\nfc\ndef\launchapp; ..\components\nfc\ndef\parser\message; ..\components\nfc\ndef\parser\record; ..\components\nfc\ndef\text; ..\components\nfc\ndef\uri; ..\components\nfc\t2t_lib; ..\components\nfc\t2t_lib\hal_t2t; ..\components\nfc\t2t_parser; ..\components\nfc\t4t_lib; ..\components\nfc\t4t_lib\hal_t4t; ..\components\nfc\t4t_parser\apdu; ..\components\nfc\t4t_parser\cc_file; ..\components\nfc\t4t_parser\hl_detection_procedure; ..\components\nfc\t4t_parser\tlv; ..\components\softdevice\common; ..\components\softdevice\s132\headers; ..\components\softdevice\s132\headers\nrf52; ..\external\fprintf; ..\external\segger_rtt; ..\integration\nrfx; ..\integration\nrfx\legacy; ..\modules\nrfx; ..\modules\nrfx\drivers\include; ..\modules\nrfx\hal; ..\modules\nrfx\mdk; ..\config; pca10040\blank\config; ..\components\toolchain\cmsis\include; s112\config; ..\components\ble\ble_link_ctx_manager; Source\Header_Files; ..\components\libraries\uart; ..\components\libraries\fifo; ..\external\segger_rtt; source\includes; s132\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: ..\components; ..\components\ble\ble_advertising; ..\components\ble\ble_dtm; ..\components\ble\ble_racp; ..\components\ble\ble_services\ble_ancs_c; ..\components\ble\ble_services\ble_ans_c; ..\components\ble\ble_services\ble_bas; ..\components\ble\ble_services\ble_bas_c; ..\components\ble\ble_services\ble_cscs; ..\components\ble\ble_services\ble_cts_c; ..\components\ble\ble_services\ble_dfu; ..\components\ble\ble_services\ble_dis; ..\components\ble\ble_services\ble_gls; ..\components\ble\ble_services\ble_hids; ..\components\ble\ble_services\ble_hrs; ..\components\ble\ble_services\ble_hrs_c; ..\components\ble\ble_services\ble_hts; ..\components\ble\ble_services\ble_ias; ..\components\ble\ble_services\ble_ias_c; ..\components\ble\ble_services\ble_lbs; ..\components\ble\ble_services\ble_lbs_c; ..\components\ble\ble_services\ble_lls; ..\components\ble\ble_services\ble_nus; ..\components\ble\ble_services\ble_nus_c; ..\components\ble\ble_services\ble_rscs; ..\components\ble\ble_services\ble_rscs_c; ..\components\ble\ble_services\ble_tps; ..\components\ble\common; ..\components\ble\nrf_ble_gatt; ..\components\ble\nrf_ble_qwr; ..\components\ble\peer_manager; ..\components\boards; ..\components\drivers_nrf\usbd; ..\components\libraries\atomic; ..\components\libraries\atomic_fifo; ..\components\libraries\atomic_flags; ..\components\libraries\balloc; ..\components\libraries\bootloader\ble_dfu; ..\components\libraries\bsp; ..\components\libraries\button; ..\components\libraries\cli; ..\components\libraries\crc16; ..\components\libraries\crc32; ..\components\libraries\crypto; ..\components\libraries\csense; ..\components\libraries\csense_drv; ..\components\libraries\delay; ..\components\libraries\ecc; ..\components\libraries\experimental_log; ..\components\libraries\experimental_log\src; ..\components\libraries\experimental_memobj; ..\components\libraries\experimental_mpu; ..\components\libraries\experimental_ringbuf; ..\components\libraries\experimental_section_vars; ..\components\libraries\experimental_stack_guard; ..\components\libraries\experimental_task_manager; ..\components\libraries\fds; ..\components\libraries\fstorage; ..\components\libraries\gfx; ..\components\libraries\gpiote; ..\components\libraries\hardfault; ..\components\libraries\hci; ..\components\libraries\led_softblink; ..\components\libraries\low_power_pwm; ..\components\libraries\mem_manager; ..\components\libraries\mutex
  OBJCOPY.OOCOutputFile: fds_example.hex
  ILINK.IlinkOutputFile: fds_example.out
  ILINK.IlinkIcfFile: s132\iar\ble_app_uart_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group application
    source/: app_fds.c main.c
    source/includes/: app_fds.h
    s132/config/: sdk_config.h
  group nrf_libraries
    ../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/fifo/: app_fifo.c
    ../components/libraries/fds/: fds.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c
    ../components/libraries/experimental_memobj/: nrf_memobj.c
    ../modules/nrfx/hal/: nrf_nvmc.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/strerror/: nrf_strerror.c
  group nrf_log
    ../components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group segger_rtt
    ../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group startup
    ../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
